## drivers/sensor/svm41/Kconfig
```kconfig
config SVM41
	bool "Sensirion SVM41"
	depends on I2C
	help
	  Enable driver for SVM41 sensor.
```
